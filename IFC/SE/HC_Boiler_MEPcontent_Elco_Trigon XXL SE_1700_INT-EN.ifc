Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-10-12T11:00:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 12 11:00:04 2018 * Host: B3ROBRAWR2785 * Database: C:\Users\LI\AppData\Local\Temp\{B728E3D3-2A14-4E60-9059-51A52F793771}\ifc * Database version: 5507 * Database creation date: Fri Oct 12 11:00:02 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Oct 12 11:00:03 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 12 11:00:03 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: 1700, HC_Boiler_MEPcontent_Elco_Trigon XXL SE_INT-EN:1700:1312803
In: V00
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 100-100-100, Color RGB 175-175-175
Type - Dimensions - Depth: 3310 mm; Drain Diameter: 40 mm; Flue Gas Diameter: 500 mm; Height: 1575 mm; Width: 1570 mm
Type - Electrical - Loads - Power: 0 W; Voltage: 400 V
Type - Electrical Engineering - Phase: 1
Type - Identity Data - Article Type: 1700; Base Family Version: 11.19; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: System Boiler; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 11.21; Manufacturer: Elco; Manufacturer URL: www.elco.net; MEPcontent Class: BOILER; Model: 1700; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2017; Type Name: 1700; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Grey: Color RGB 100-100-100; Light Grey: Color RGB 175-175-175; White: Color RGB 216-216-216
Type - Mechanical - Loads - Efficiency at 40/30ºC full load (%): 93.53; Efficiency at 80/60ºC full load (%): 92.55; Nominal heat output at 40-30ºC max: 18121043; Nominal heat output at 80-60ºC max: 17931598; Power Consumption Boiler: 29816
Type - Other - Category: Mechanical Equipment; B1: 190 mm; B3: 195 mm; B5: 1375 mm; B6: 0 mm; Back Clearance: 930 mm; Body Depth: 2600 mm; Burner 1: no; Burner 2: yes; Compensator Diameter: 350 mm; Compensator Radius: 177 mm; Connection 1 Length: 480 mm; Connection 2 Length: 0 mm; Connections 1: no; Connections 2: yes; Cut Length: 325 mm; D: 500 mm; Drain Height: 161 mm; Drain Width: 820 mm; Family Name: HC_Boiler_MEPcontent_Elco_Trigon XXL SE_INT-EN; Feet Offset: 1524 mm; Flue Gas Height: 490 mm; Flue Gas Width: 350 mm; Front Clearance: 1000 mm; G: 88.9 mm; H1: 915 mm; H2: 440 mm; H3: 490 mm; H4: 260 mm; Height G: 440 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; Left Clearance: 800 mm; Lenght 1.1: 512 mm; Lenght 1.2: 678.5 mm; Lenght 1.3: 678.5 mm; Lenght 2.1: 512 mm; Lenght 2.2: 968 mm; Lenght 2.3: 968 mm; Length 3.1: 2449 mm; Length 3.2: 1 mm; Length G: 1140 mm; Offset: 115 mm; Offset Water Down: 1375 mm; Right Clearance: 450 mm; Vertical Offset Water Down: 260 mm; W: 88.9 mm; Water Connection Offset: 1225 mm; Width G: 190 mm
Type - Text - Article Description: System Boiler; GTIN: 5414849769304; Manufacturer Art. No.: 3581755; Product Line: Trigon XXL
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 39.2167 m2; Gas Connection Diameter: 80 mm; Hydronic Supply Diameter: 80 mm; Use Nominal Diameter: yes; Volume: 5.86536 m3
Identity Data - Mark: 4
Mechanical - System Classification: Hydronic Supply,Undefined,Sanitary,Power,Other
Mechanical - Flow - Drain Fixture Units: 0; Flow Gas: 0 m3/s; Flue Gas Flow: 0 m3/s; Hydronic Supply Flow 1: 0 m3/s; Hydronic Supply Flow 2: 0 m3/s
Other - Family: HC_Boiler_MEPcontent_Elco_Trigon XXL SE_INT-EN: 1700; Family and Type: HC_Boiler_MEPcontent_Elco_Trigon XXL SE_INT-EN: 1700; Flange Offset: 45 mm; Type: HC_Boiler_MEPcontent_Elco_Trigon XXL SE_INT-EN: 1700; Type Id: HC_Boiler_MEPcontent_Elco_Trigon XXL SE_INT-EN: 1700; Water Connector Offset: 0 mm
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Counter Flange: no; Show Service Area: no
